# Keil uVision project DALI_Control_Device.uvprojx, settings and files
target DALI_Control_Device (6190000::V6.19::ARMCLANG)
  device: NDA102SD2 Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.4
  cpu: IRAM(0x20000000,0x3000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: DALI_Control_Device
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEMOBOARD = 0
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\DALIDriver\DALI_Driver;..\..\..\Library\DALIDriver\DALI_Library;..\..\DALI_Control_Device;..\..\..\Library\ssd1306;..\..\..\Library\Device\Nuvoton\NDA102\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000200 size 0x2e00
  link misc: --map --first='startup_NDA102.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/NDA102/Source/: system_NDA102.c
    ../../../Library/Device/Nuvoton/NDA102/Source/ARM/: startup_NDA102.s
  group Library
    ../../../Library/StdDriver/src/: retarget.c uart.c sys.c clk.c fmc.c gpio.c pwm.c timer.c eadc.c acmp.c i2c.c rtc.c
  group User
    ../: main.c board_init.c dali_cd_manufacturer_mode.c EEPROM_Emulate.c ALS.c
  group DALI_App
    ../../../Library/DALIDriver/DALI_Driver/: dali_addressing_16.c dali_addressing_24.c dali_app_gear.c
  group DALI_Driver
    ../../../Library/DALIDriver/DALI_Driver/: dali_cd_103_init.c dali_cd_301_init.c dali_cd_302_init.c dali_cd_303_init.c dali_cd_304_init.c dali_cd_app.c dali_cd_bank.c dali_cd_event.c dali_cd_receive.c dali_cd_transmit.c dali_fmc.c dali_gen_randAddr.c
    ../../../Library/DALIDriver/DALI_Library/: DALI_Control_Device.lib
  group DEMO
    ../../../Library/ssd1306/: ssd1306.c ssd1306_fonts.c ssd1306_tests.c hal_tick_control.c
software components: CMSIS:CORE 6.1.0
